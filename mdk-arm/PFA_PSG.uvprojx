# Keil uVision project PFA_PSG.uvprojx, settings and files
target Target_1 (6230000::V6.23::ARMCLANG)
  device: STM32G474QETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PFA_PSG +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\vendored\zephyr\include;..
  asm include: ..\vendored\zephyr\include;..
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\board\stm32g474\stm32g474.sct
  group app
    ../app/: app.c
  group board
    ../board/: board.c devices.c
  group board/stm32g474
    ../board/stm32g474/: main.c system_stm32g474.c startup_stm32g474.s
  group drivers
    ../drivers/clock_control/: clock_stm32.c
    ../drivers/gpio/: gpio_stm32.c
  group osal
    ../osal/: osal.c
  group service
    ../service/heartbeat/: heartbeat.c
  group vendored/zephyr
    ../vendored/zephyr/src/: init.c device.c logging.c assert.c
